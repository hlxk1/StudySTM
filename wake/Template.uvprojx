# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS;.\APP\led;.\Public;.\APP\beep;.\APP\smg;.\APP\key;.\APP\motor;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\usart;.\APP\iwdg;.\APP\wwdg;.\APP\inputCatch;.\APP\wakeup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
    ./APP/pwm/: pwm.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_pwr.c
    ../EXTI/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group APP
    ./APP/led/: led.c
    ./APP/beep/: beep.c
    ./APP/smg/: smg.c
    ./APP/key/: key.c
    ./APP/motor/: dc_motor.c step_motor.c
    ./APP/exti/: EXTI.c
    ./APP/time/: TIM.c
    ./APP/usart/: usart.c
    ./APP/iwdg/: iwdg.c
    ./APP/wwdg/: wwdg.c
    ./APP/inputCatch/: inputCatch.c
    ./APP/wakeup/: wakeup.c
  group Public
    ./Public/: system.c systick.c
